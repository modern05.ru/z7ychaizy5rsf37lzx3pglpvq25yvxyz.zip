Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-06-07T12:12:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220224_1700(x64) - Exporter 19.2.60.3 - Alternate UI 19.2.60.3
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Jun 07 12:12:13 2022* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{BA05D9CE-6731-456E-91C3-674D5AB83F3B}\ifc* Database version: 5507* Database creation date: Tue Jun 07 12:12:12 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Jun 07 12:12:12 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Jun 07 12:12:12 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: C02000, NBS_VilleroyAndBochAG_VntyUnits_Collaro_VanityUnit_C02000:C02000:109321
In: Level 1
Type - ElementType: C02000; Material: NBS_VilleroyAndBoch_WhiteMatt
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_VanityUnits_Collaro_VanityUnit_C02000; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/ubp4ahn2; ProductInformation: https://pro.villeroy-boch.com/en/euo/bw/m/C02000; Uniclass2015Title: Vanity units; Uniclass2015Code: Pr_40_20_76_94; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; Form: Wall-mounted; Handles: Anthracite matt; IntegralAccessories: Washbasin; MaterialsCarcassFinishAndColour: Oak Kansas; MaterialsCarcassFrameAndPanels: Chipboard; Recyclability: n/a; RecycledContent: n/a; SizeNominal: 1000 x 548 x 500 mm; WorktopFinishAndColour: Oak Kansas; WorktopMaterials: Chipboard
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_76_94:Vanity units; CodePerformance: n/a; Color: Brown; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Direct coating, Matt; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: Aluminium, Glass, Chipboard; ModelNumber: C02000; ModelReference: Collaro_VanityUnit_C02000; Name: VanityUnits_Collaro_VanityUnit_C02000_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: Rectangle; Size: 1000 x 548 x 500 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
